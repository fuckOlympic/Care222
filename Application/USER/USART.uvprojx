# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OBJ\UV_lamp.bin ..\OBJ\USART.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F446xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\HARDWARE\WWDG;..\HARDWARE\IIC;..\HARDWARE\ADC;..\HARDWARE\24CXX;..\HARDWARE\FAN_MOTOR;..\HARDWARE\DMA;..\HARDWARE\PWM;..\HARDWARE\LM75ADP;..\HARDWARE\PIR;..\HARDWARE\TIMER;..\SYSTEM\usart1;..\FUNCTION;..\HARDWARE\UV_LAMP;..\HARDWARE\RTC;..\HARDWARE\STMFLASH;..\HARDWARE\EEPROM;..\HARDWARE\TCA9555;..\USB\inc;..\HARDWARE\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c Config.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WWDG/: wwdg.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/FAN_MOTOR/: fan_motor.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/LM75ADP/: lm75adp.c
    ../HARDWARE/PIR/: pir.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/UV_LAMP/: uv_lamp.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/EEPROM/: eeprom.c eeprom.h
    ../HARDWARE/TCA9555/: tca9555.c
    ../HARDWARE/IWDG/: iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart1/: usart1.c
  group CORE
    ../CORE/: startup_stm32f446xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dbgmcu.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_flash.c
  group README
    ../: readme.txt
  group FUNCTION
    ../FUNCTION/: function.c TestComm.h
    ./: TestComm.c
  group USB
    ../USB/src/: usbd_cdc_vcp.c usbd_desc.c usbd_usr.c usbd_cdc_core_loopback.c usb_bsp.c
  group USBDevice
    ../USB/src/: usbd_req.c usbd_ioreq.c usbd_core.c
  group USBDriver
    ../USB/src/: usb_dcd_int.c usb_dcd.c usb_core.c
